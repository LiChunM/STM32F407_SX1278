# Keil uVision project UCOSII-3.uvproj, settings and files
target UCOSII-3 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: WLW_V2_1 +hex
  c flags: Optim=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\FWLIB\inc;..\HARDWARE\TOUCH;..\HARDWARE\BEEP;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\TPAD;..\MALLOC;..\HARDWARE\GC65;..\HARDWARE\POWER;..\HARDWARE\RTC;..\HARDWARE\STMFLASH;..\HARDWARE\USART2;..\HARDWARE\USART3;..\HARDWARE\USART6;..\Protocol;..\HARDWARE\ADC;..\HARDWARE\SX1278;..\HARDWARE\SPI;..\HARDWARE\SX1278\platform\sx12xxEiger;..\HARDWARE\SX1278\platform;..\HARDWARE\SX1278\radio;..\HARDWARE\W25QXX;..\HARDWARE\SLEEP;..\HARDWARE\famen
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/USART6/: usart6.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/POWER/: power_drv.c
    ../HARDWARE/GC65/: mc323.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SLEEP/: sleep.c
    ../HARDWARE/famen/: famen.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f4xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c stm32f4xx_adc.c stm32f4xx_spi.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group PROTOCOL
    ../Protocol/: Protocol.c sxdowndata.c sxprotocol.c
  group SX1278
    ../HARDWARE/SX1278/radio/: radio.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
    ../HARDWARE/SX1278/platform/sx12xxEiger/: fifo.c spi.c sx12xxEiger.c sx1276-Hal.c
